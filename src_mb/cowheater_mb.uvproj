# Keil uVision project cowheater_mb.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: cowheater_mb +hex
  c flags: Optimize=8 SizeSpeed=1
  group ASM
    ./: STARTUP.A51
  group APP
    ./Sources/app/: main.c
